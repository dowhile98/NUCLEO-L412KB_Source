# Keil uVision project SPI_SLAVE_F103.uvprojx, settings and files
target STM32F103C8 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI_SLAVE_F103
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Scr
    ./: main.c Delay.c retarget.c USART.c
  group Inc
    ./: Delay.h USART.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
