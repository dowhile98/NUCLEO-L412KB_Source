# Keil uVision project RTOS_freeRTOS.uvprojx, settings and files
target NUCLEO-L412KB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L412KBUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: RTOS_freeRTOS
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\MiddleWare\ThirdParty\FreeRTOS\include;.\MiddleWare\ThirdParty\FreeRTOS\portable\RVDS\ARM_CM4F;..\RTOS_freeRTOS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Scr
    ./: main.c USART.c retarget.c Delay.c
  group Inc
    ./: FreeRTOSConfig.h USART.h Delay.h
  group FreeRTOS
    ./MiddleWare/ThirdParty/FreeRTOS/portable/MemMang/: heap_4.c
    ./MiddleWare/ThirdParty/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./MiddleWare/ThirdParty/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.3.1
