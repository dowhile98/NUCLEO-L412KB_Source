# Keil uVision project LCD 16x2.uvprojx, settings and files
target NUCLEO-F401RE (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD 16x2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Scr
    ./: main.c LCD16x2.c delay.c KEYPAD4X4.c
  group Inc
    ./: LCD16x2.h delay.h KEYPAD4X4.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
