# Keil uVision project SPI.uvprojx, settings and files
target NUCLEO-L412KB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L412KBUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: SPI
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Scr
    ./: main.c Delay.c RCC.c retarget.c USART.c SPI.c
  group Inc
    ./: RCC.h USART.h Delay.h SPI.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.3.1
